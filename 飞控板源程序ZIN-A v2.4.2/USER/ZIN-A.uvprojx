# Keil uVision project ZIN-A.uvprojx, settings and files
target ZIN-A (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM;..\HAL;..\MATH;..\CONFIG;..\USBStack\SRC;..\USBStack\INC;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: ALL_DATA.h ALL_DEFINE.h INIT.c scheduler.c
  group CONFIG
    ../CONFIG/: ADC.c CAN.c SPI.c TIM.c TIM_IN.c TIM_OUT.c USART1.c USART2.c USART3.c USART4.c USART5.c USART6.c I2C_hardware.c usbd_user_hid.c usbd_STM32F4xx_FS.c
  group HARDWARE
    ../HARDWARE/: LED.c mpu6050.c US100.c AT24C02.c ak8975.c spl06.c GPS.c nrf24l01.c osc.c senror.c
  group HAL
    ../HAL/: ANO_DT.c remote.c control.c high_process.c attitude_process.c postion_process.c
  group MATH
    ../MATH/: filter.c myMath.c pid.c imu.c
  group USB
    ../USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c version.c usb_config.c
  group README
    ../: readme.txt
